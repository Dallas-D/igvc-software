Commit message: hacky testing changes

File: gazebo/igvc_description/urdf/Jaymii.urdf (robot description, URDF)
Before this commit: robot Jaymii, 17 links, 16 joints
Joints:
- joint base_footprint_to_lidar: origin xyz=0.4572 0 0.9525 rpy=0 0 0 -> xyz=0.27 0 0.9525 rpy=0 0 0
